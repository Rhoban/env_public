Commit message: Updating ROI for balls

File: mowgly/mowgly.urdf (robot description, URDF)
Before this commit: robot metabot, 26 links, 25 joints
Joints:
- joint camera: origin xyz=0.01 1.59872e-17 0.062 rpy=0 0.07 -0.07 -> xyz=0.01 1.59872e-17 0.062 rpy=0 0.0 0.0
